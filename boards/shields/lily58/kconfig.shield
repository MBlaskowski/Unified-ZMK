## boards/shields/lily58/kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_lily58_DONGLE
    def_bool $(shields_list_contains,prospector_adapter)
```
